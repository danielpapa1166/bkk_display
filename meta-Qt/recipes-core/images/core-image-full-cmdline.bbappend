IMAGE_INSTALL:append = "    \
    qtbase                  \
    liberation-fonts        \
    bkk-screen-owner        \
    bkk-helper              \
    bkk-screen-info-bar     \
"