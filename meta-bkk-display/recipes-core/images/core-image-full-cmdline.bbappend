IMAGE_INSTALL:append = "        \
    bkk-api                     \
    bkk-api-test                \
    rbuflogd                    \
    config-server               \
    ads7846-demo                \
    application-manager         \
    optee-client                \
    optee-test                  \
    bkk-tee                     \
    valgrind                    \
    bkk-screen-fb-playground    \
    network-manager             \
    network-manager-dev         \
    qr-code-gen                 \
"
