FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://ads7846-touchscreen.cfg"
SRC_URI += "file://optee.cfg"
