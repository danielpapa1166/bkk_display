# Allow optee-test (xtest) to build for raspberrypi4-64.
# The default COMPATIBLE_MACHINE in optee.inc is "invalid".

COMPATIBLE_MACHINE:raspberrypi4-64 = "raspberrypi4-64"
