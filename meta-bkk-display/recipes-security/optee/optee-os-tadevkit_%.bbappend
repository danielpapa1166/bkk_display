# Allow optee-os-tadevkit to build for raspberrypi4-64.
# This recipe requires optee-os and inherits OP-TEE platform settings.

COMPATIBLE_MACHINE:raspberrypi4-64 = "raspberrypi4-64"
OPTEEMACHINE:raspberrypi4-64 = "rpi3"
