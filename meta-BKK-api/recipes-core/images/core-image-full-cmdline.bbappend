IMAGE_INSTALL:append = " bkk-api"
IMAGE_INSTALL:append = " bkk-api-test"
IMAGE_INSTALL:append = " rbuflogd"
IMAGE_INSTALL:append = " c-http-server"