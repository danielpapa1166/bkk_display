IMAGE_INSTALL:append = " \
    bkk-api             \
    bkk-api-test        \
    rbuflogd            \
    config-server       \
    ads7846-demo        \
    application-manager \
"
