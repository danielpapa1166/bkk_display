IMAGE_INSTALL:append = " ads7846-demo"